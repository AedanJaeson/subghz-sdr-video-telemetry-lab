options:
  parameters:
    generate_options: qt_gui
    id: receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: channel_rate
  id: variable
  parameters:
    value: samp_rate / decim
  states: {}
- name: decim
  id: variable
  parameters:
    value: '16'
  states: {}
- name: freq_dev
  id: variable
  parameters:
    value: 5e3
  states: {}
- name: quad_gain
  id: variable
  parameters:
    value: channel_rate / (2 * 3.141592653589793 * freq_dev)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.04e6
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: quad_gain
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-127.5'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-127.5'
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Aedan\dev\subghz-sdr-video-telemetry-lab\captures\example_iq\cc1101_test1.cu8
    length: '489600'
    offset: '1632000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '16'
    max_iter: '4000'
    scale: 1 / 64
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: '2040'
    max_iter: '4000'
    scale: 1.0 / 2040
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/127
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/127
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate / 2
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '25000'
    decim: decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    alias: RTL SDR bytes
    comment: RTL SDR file gives bytes 0 to 255
  states: {}
- name: note_1
  id: note
  parameters:
    comment: .cu8 samples are stored as unsigned 8-bit integers, but DSP blocks expect samples centered around zero.
  states: {}
- name: note_2
  id: note
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Raw signal"'
    size: '32768'
    srate: channel_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"power time sink"'
    size: '32768'
    srate: channel_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"sliced bits"'
    size: '32768'
    srate: channel_rate
    type: float
    ymax: '1.2'
    ymin: '-0.2'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_deinterleave_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_deinterleave_0, '1', blocks_add_const_vxx_0_0, '0']
- [blocks_file_source_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_moving_average_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_moving_average_xx_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_throttle2_0, '0', low_pass_filter_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_deinterleave_0, '0']
- [blocks_uchar_to_float_1, '0', qtgui_time_sink_x_2, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_1, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
